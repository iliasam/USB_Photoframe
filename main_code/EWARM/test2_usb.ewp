# IAR project test2_usb.ewp, settings and files
configuration test2_usb Configuration (ARM, debug)
  General.OGChipSelectEditMenu: STM32F107xC ST STM32F107xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F107xC; HSE_VALUE=25000000
  ICCARM.CCIncludePath2: ..\Inc; ..\Src; ..\decoder; ..\icons; ..\Drivers\STM32F1xx_HAL_Driver\Inc; ..\Drivers\STM32F1xx_HAL_Driver\Inc\Legacy; ..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ..\Middlewares\ST\STM32_USB_Device_Library\Class\MSC\Inc; ..\Drivers\CMSIS\Include; ..\Drivers\CMSIS\Device\ST\STM32F1xx\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: test2_usb.hex
  ILINK.IlinkOutputFile: test2_usb Configuration.out
  ILINK.IlinkIcfFile: stm32f107xc_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/iar/: startup_stm32f107xc.s
  group Application/User
    ../Src/: emfat.c gpio.c image_render.c main.c stm32f1xx_hal_msp.c stm32f1xx_it.c string_render.c usart.c usb_device.c usbd_conf.c usbd_desc.c usbd_storage_if.c wifi.c wifi_functions.c wifi_strings.c
  group Application/User/icons
    ../icons/: broken_clouds_icon.h error_icon.h few_clouds_icon.h icon_names.h rain_icon.h scattered_clouds_icon.h shower_rain_icon.h snow_icon.h sun_icon.h thunderstorm_icon.h
  group Application/User/Inc
    ../Inc/: emfat.h image_render.h main.h string_render.h usb_device.h usbd_conf.h usbd_desc.h usbd_storage_if.h wifi.h
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_uart.c stm32f1xx_ll_usb.c
  group mcufont
    ../decoder/: DejaVuSans48rus.h mcufont.h mf_bwfont.c mf_bwfont.h mf_config.h mf_encoding.c mf_encoding.h mf_font.c mf_font.h mf_justify.c mf_justify.h mf_kerning.c mf_kerning.h mf_rlefont.c mf_rlefont.h mf_scaledfont.c mf_scaledfont.h mf_wordwrap.c mf_wordwrap.h
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
